# Keil uVision project cfg_demo.uvprojx, settings and files
target cfg_jtag (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cfg_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F103RCT6_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Source\cfg_jtag;..\..\Source\common;..\..\Libraries;..\..\Libraries\key;..\..\Libraries\led;..\..\Libraries\spi;..\..\Libraries\usart;..\..\Libraries\Libraries\CMSIS;..\..\Libraries\Libraries\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../../Libraries/Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../Source/cfg_jtag/: hardware.c pango_jtag.c fpga_jtag_basic.c fpga_jtag_demo.c
  group THIRDPARTY
    ../../Libraries/key/: bsp_key.c
    ../../Libraries/led/: bsp_led.c
    ../../Libraries/spi/: bsp_spi.c
    ../../Libraries/usart/: bsp_usart1.c
  group DOC
    ../../Doc/cfg_jtag/: readme.txt
